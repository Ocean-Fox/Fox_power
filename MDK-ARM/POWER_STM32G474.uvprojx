# Keil uVision project POWER_STM32G474.uvprojx, settings and files
target POWER_STM32G474 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32G474CEUx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x2001FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: POWER_STM32G474 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32G474xx
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../communication;../ADC_Init;../user;../pid
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Application/User/Core
    ./: startup_stm32g474xx.s
    ../Core/Src/: fliter.c main.c gpio.c adc.c dma.c fdcan.c fmac.c hrtim.c opamp.c tim.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c
    ../Core/Inc/: fliter.h
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_adc.c stm32g4xx_hal_adc_ex.c stm32g4xx_ll_adc.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_fdcan.c stm32g4xx_hal_fmac.c stm32g4xx_hal_hrtim.c stm32g4xx_hal_opamp.c stm32g4xx_hal_opamp_ex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
  group communication
    ../communication/: fdcan_Init.c fdcan_Init.h vofa_float.c vofa_float.h
  group ADC_Init
    ./: ADC_.c
    ../ADC_Init/: ADC_.h
  group user
    ../user/: TIM_Init.c TIM_Init.h power_control_fox.c power_control_fox.h function.c function.h
  group pid
    ../pid/: Pid_Init.c Pid_Init.h pid.c pid.h struct_typedef.h
software components: CMSIS:CORE 6.1.0, CMSIS:DSP 1.16.2
